Commit message: anonymize car model

File: control_tree_car/data/urdf/car.urdf (robot description, URDF)
Before this commit: robot lgp_car, 1 links, 0 joints
Links:
- link lgp_car: geometry visual mesh filename=package://control_tree_car/data/meshes/car/car.dae
